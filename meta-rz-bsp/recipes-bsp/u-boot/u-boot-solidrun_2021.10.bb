require u-boot-renesas.inc

COMPATIBLE_MACHINE = "(rzg2h-family|rzg2l-family)"

SRCREV = "a230e5df53a34de412a4defed1b3c430b2c4cceb"
BRANCH = "v2021.10/rz-sr"
UBOOT_URL = "git://github.com/SolidRun/u-boot.git"

LIC_FILES_CHKSUM = "file://Licenses/README;md5=5a7450c57ffe5ae63fd732446b988025"
