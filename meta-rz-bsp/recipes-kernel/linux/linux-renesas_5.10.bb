DESCRIPTION = "Linux kernel from the Renesas RZ BSP v3.0.6-update4 based on \
	linux-5.10.y-cip"

require linux.inc

KERNEL_URL = "git://github.com/renesas-rz/rz_linux-cip.git"
KBRANCH = "rz-5.10-cip41"
SRCREV = "9e113d74d2ab12af3e8aec11977e570d1fa8610a"

LINUX_VERSION = "5.10.201-cip41"
