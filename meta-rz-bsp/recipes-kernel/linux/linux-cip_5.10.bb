DESCRIPTION = "CIP SLTS Linux kernel v5.10"

require linux.inc

KERNEL_URL = "git://gitlab.com/cip-project/cip-kernel/linux-cip.git"
KBRANCH = "linux-5.10.y-cip"
SRCREV = "6077b17f20b1bcfeccaa23bc05573b938c47679d"

LINUX_VERSION = "5.10.233-cip56"
