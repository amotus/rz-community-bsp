DESCRIPTION = "CIP SLTS Linux kernel v6.1"

require linux.inc

KERNEL_URL = "git://gitlab.com/cip-project/cip-kernel/linux-cip.git"
KBRANCH = "linux-6.1.y-cip"
SRCREV = "4fcefd04cf3c247e3ce647185fb4f2ae07a24dca"

LINUX_VERSION = "6.1.128-cip37"
